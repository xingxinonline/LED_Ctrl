# Keil uVision project STM32-LedCrtl.uvprojx, settings and files
target LED-Ctrl (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LEDCTRL_RESOURCE_V_1_8_20180202 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;.\USER;..\FWlib\inc;..\FWlib\src;.\inc;.\USER\DS3231;.\USER\IIC;.\USER\CAPACITY;.\USER\MENU;.\USER\TASK;.\USER\LOWPOWER;.\USER\BKP;.\USER\SCREEN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_rtc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Readme
    ../: readme.txt
  group USER
    ./USER/: stm32f10x_it.c delay.c sys.c spi.c flash.c CRC16.C stmflash.c utils.c timer.c config.c datadeal.c GlobalVar.c usart.c main.c Debug.c
    ./USER/DS3231/: DS3231.c
    ./USER/IIC/: myiic.c
    ./USER/CAPACITY/: capacity.c
    ./USER/MENU/: menu.c
    ./USER/TASK/: task.c
    ./USER/LOWPOWER/: lowpower.c
    ./USER/BKP/: bkp.c
    ./USER/SCREEN/: screen.c
software components: CMSIS:CORE 4.3.0
